# IAR project provisioning_smartconfig.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; NOTERM
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\..\common\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink\; ..\..\..\simplelink\source; ..\..\..\simplelink\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: provisioning_smartconfig.bin
  ILINK.IlinkOutputFile: provisioning_smartconfig.out
  ILINK.IlinkConfigDefines: Flash=0; CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\..\..\driverlib\ewarm\Release\Exe\driverlib.a; ..\..\..\simplelink\ewarm\NON_OS\Exe\simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../common/: gpio_if.c startup_ewarm.c
    ../: main.c pinmux.c
